# IAR project Tm4cApp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: C:\Program Files (x86)\IAR Systems\Embedded Workbench 8.0\arm\inc\TexasInstruments
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Tm4cApp.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: Tm4cApp.hex
  ILINK.IlinkIcfFile: Tm4cApp.icf
  ILINK.IlinkProgramEntryLabel: App_main
  group (top)
    ./: main.c Tm4cApp.icf
