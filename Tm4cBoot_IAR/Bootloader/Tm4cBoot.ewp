# IAR project Tm4cBoot.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: C:\Program Files (x86)\IAR Systems\Embedded Workbench 8.0\arm\inc\TexasInstruments; C:\ti\TivaWare_C_Series-2.2.0.295\driverlib\ewarm\Exe; C:\ti\TivaWare_C_Series-2.2.0.295\driverlib; C:\ti\TivaWare_C_Series-2.2.0.295\inc; C:\ti\TivaWare_C_Series-2.2.0.295\driverlib\ewarm; C:\ti\TivaWare_C_Series-2.2.0.295\examples
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Tm4cBoot.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkKeepSymbols: APP_CODE
  ILINK.IlinkIcfFile: Tm4cBoot.icf
  ILINK.IlinkProgramEntryLabel: Boot_main
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: Bootloader.c Bootloader.h Config.h crc.c crc.h main.c packet.c packet.h System_Config.h Tm4cBoot.icf
