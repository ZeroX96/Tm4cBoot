<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Tm4cApp_IAR.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Tm4cBoot_IAR.ewp</path>
    </project>
    <batchBuild />
</workspace>
